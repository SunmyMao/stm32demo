# Keil uVision project stm32demo.uvproj, settings and files
target stm32demo (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32demo +hex
  c flags: Optim=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: .\STM32F10x_StdPeriph_Driver\inc;.\usr-src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group system-lib
    ./usr-src/: stm32f10x_conf.h system_stm32f10x.c
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c
  group usr-src
    ./usr-src/: steering_engine.h main.c steering_engine.c
